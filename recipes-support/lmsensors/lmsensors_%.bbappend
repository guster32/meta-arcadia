PACKAGE_EXCLUDE_${PN} = " ${PN}-isatools ${PN}-isatools-dbg ${PN}-isatools-doc"
RDEPENDS_${PN}_remove = "${PN}-isatools ${PN}-isatools-dbg ${PN}-isatools-doc"
